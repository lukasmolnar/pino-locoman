Commit message: fix b2g formulation, update urdfs

File: robots/b2g_description/urdf/b2g.urdf (robot description, URDF)
Before this commit: robot b2g_description, 47 links, 46 joints
Links:
- link base_inertia: mass 35.86 -> 33.86
